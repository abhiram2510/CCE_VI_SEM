	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000 
	DCD Reset_Handler 
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R4,=RESULT
	LDRB R2,[R0]
	AND R3,R2,#0X0F
	CMP R3,#0X09
	BMI CON
	BEQ CON
	ADD R3,#07
CON ADD R3,#0X30
	STRB R3,[R4]
	LSR R3,R2,#4
	CMP R3,#0X09
	BMI CON1
	BEQ CON1	
	ADD R3,#07
CON1 ADD R3,#0X30
	STRB R3,[R4,#01]
	
NUM DCD 0x000005A
	AREA data, DATA, READWRITE
RESULT DCD 0
	END