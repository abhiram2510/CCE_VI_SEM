;non-Overlapping
	AREA reset, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000 
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R0 ,=SRC
	LDR R1 ,=DST
	MOV R6,#10
	MOV R7,#10
LOOP2
	LDR R2,[R0],#4
	STR R2,[R1],#4
	SUBS R6 ,#1
	BNE LOOP2
	
	LDR R0,=DST
	LDR R1,=0x10000040
LOOP
	LDR R8,[R0],#4
	STR R8,[R1],#4
	SUBS R7 ,#1
	BNE LOOP
STOP
	B STOP
SRC DCD 0xD87FC5A7,0x8D33CD38,0x9FAB89A2,0xA257C901,0xAFCB6BFD,0x3992F81C,0xC9E69770,0x66ECCC79,0x1F8FCC04,0x8809CC93
	AREA DATASEG, DATA, READWRITE
DST DCD 0
	END