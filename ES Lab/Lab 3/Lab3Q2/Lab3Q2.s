	AREA reset, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	MOV R0,#56
	MOV R1,#35
	LDR R7,=DST

UP CMP R0,R1
	BEQ GCD
	BCS DIV
	MOV R3,R0
	MOV R4,R1
	MOV R1,R3
	MOV R0,R4
	B DIV

DIV SUB R0,R1
	CMP R0,R1
	BCS DIV
	CMP R0,#0
	BEQ GCD
	B UP

GCD STR R1,[R7]

STOP
	B STOP
	AREA data, DATA,READWRITE
DST DCD 0x0	
	END