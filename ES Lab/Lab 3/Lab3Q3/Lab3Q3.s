	AREA reset, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	MOV R0,#2
	MOV R1,#3
	LDR R7,=DST
	MUL R5,R0,R1
	MOV R6,#0

UP CMP R0,R1
	BEQ LCM
	BCS DIV
	MOV R3,R0
	MOV R4,R1
	MOV R1,R3
	MOV R0,R4
	B DIV

DIV SUB R0,R1
	CMP R0,R1
	BCS DIV
	CMP R0,#0
	BEQ LCM
	B UP

LCM SUB R5,R1
	ADD R6,#1
	CMP R5,R1
	BCS LCM
	STR R6,[R7]

STOP
	B STOP
	AREA data, DATA,READWRITE
DST DCD 0x0	
	END